# Keil uVision project KEYPAD.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KEYPAD +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Source Group 1
    ./: startup_stm32f10x_ld.s delay.c I2C.c keypad.c main.c
